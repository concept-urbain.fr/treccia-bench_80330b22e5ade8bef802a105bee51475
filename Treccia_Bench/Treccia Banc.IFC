Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Treccia Banc.IFC
Time: 2023-07-26T07:26:16
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 100712_Default (8)
In: Default Storey
Material: Inox A2-70

# IfcBuildingElementProxy: 105335_Default (2)
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: 105378_Default (16)
In: Default Storey
Name
105378_Default | PSet_Mass_Property - Mass Measure: 60.0789; Area Measure: 4.85967 m2; Volume Measure: 0.00780222 m3
15 x 105378_Default
